# Keil uVision project touch_button.uvprojx, settings and files
target touch_button (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IROM(0x00000000,0x00080000) IRAM(0x20000000,0x00010000) IRAM2(0x00800000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: touch_button
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_PCA10040 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\..\..\commons\led;..\..\..\..\..\commons\button;..\..\..\..\..\components;..\..\..\..\..\components\libraries\delay;..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\modules\nrfx;..\config;..\..\..\..\..\integration\nrfx;..\..\..\..\..\components\libraries\util;..\..\..\..\..\modules\nrfx\drivers;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\components\libraries\balloc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x800000 size 0x10000
  group app
    ../../../: main.c
  group commons_led
    ../../../../../commons/led/: led.c
  group commons_touch_btn
    ../../../../../commons/button/: touch.c
software components: CMSIS:CORE 5.3.0, Device:Startup 8.35.0
